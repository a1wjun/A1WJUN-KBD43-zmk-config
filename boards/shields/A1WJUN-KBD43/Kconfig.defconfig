## boards/shields/A1WJUN-KBD43/Kconfig.defconfig
```kconfig
if SHIELD_A1WJUN-KBD43

config ZMK_KEYBOARD_NAME
    default "A1WJUN-KBD43"

endif
```
